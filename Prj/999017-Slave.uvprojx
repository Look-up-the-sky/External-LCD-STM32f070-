# Keil uVision project 999017-Slave.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F070CB STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: 999017-Slave +hex
  AfterMake: D:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin --output ./bin/999017-Slave.bin ./999017-Slave.axf
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c misc: --c99
  c include: ..\Include;..\LibStm32\Header;..\OmnikLib\H_Files;..\OmnikLib
  memory RVCT4: ROM 0x8002800 size 0x1d400
  memory RVCT9: RAM 0x20000000 size 0x100
  memory RVCT10: RAM 0x20000100 size 0x3f00
  group App
    ../App/: Main.c startup_stm32f070xb.s Initial.c Display.c Interrupt.c I2C.c Eeprom.c Pcf8563.c debug.c Modbus.c MF_Datecfg.c HF_Datecfg.c Crc.c Variable_Transformation.c Led_State.c config.lib
  group LibStm32
    ../LibStm32/Source/: stm32f0xx_adc.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c system_stm32f0xx.c
  group OmnikLib
    ../OmnikLib/C_Files/: Lib_CRC.c Lib_Sqrt.c Lib_task.c Lib_SlaveCom.c Lib_Communication.c Lib_ClearRam.c Lib_Country.c
